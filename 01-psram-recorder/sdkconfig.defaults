## 01-psram-recorder/sdkconfig.defaults.esp32c5
```kconfig
CONFIG_ESPTOOLPY_FLASHSIZE_8MB=y
CONFIG_ESP_DEFAULT_CPU_FREQ_MHZ_240=y

# 8 MB quad PSRAM
CONFIG_SPIRAM=y
CONFIG_SPIRAM_SPEED_80M=y
```
